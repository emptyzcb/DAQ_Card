# Keil uVision project F430VI.uvprojx, settings and files
target F430VI (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: F430VI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../BSP/Inc;../Application/Inc;../Platform/Inc;../Services/Inc
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c fdcan.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application
    ../Application/Src/: app.c ALL_Task.c Task_digital_io.c Task_modbus_rtu.c Task_io_logic.c Task_ad7606.c Task_eth.c sys.c
    ../Application/Inc/: app.h ALL_Task.h Task_digital_io.h Task_modbus_rtu.h Task_io_logic.h Task_ad7606.h Task_eth.h sys.h
  group BSP
    ../BSP/Src/: bsp_console.c bsp_led.c bsp_ad7606.c bsp_analog_output.c bsp_digital_io.c bsp_pulse_counter.c bsp_encoder_input.c bsp_w25q128.c bsp_w5500.c
    ../BSP/Inc/: bsp_ad7606.h bsp_analog_output.h bsp_digital_io.h bsp_pulse_counter.h bsp_encoder_input.h bsp_w25q128.h bsp_w5500.h board_pins.h
  group Platform
    ../Platform/Src/: platform.c
  group Services
    ../Services/Src/: led_blink.c datahub.c ad7606_service.c rs485_uart.c modbus_rtu.c modbus_tcp.c modbus_master.c modbus_register_map.c can_service.c digital_io_service.c io_config_storage.c io_logic_engine.c io_logic_protocol.c
    ../Services/Inc/: ad7606_service.h rs485_uart.h modbus_rtu.h modbus_tcp.h modbus_master.h modbus_register_map.h can_service.h digital_io_service.h io_config_storage.h io_logic_engine.h io_logic_protocol.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_qspi.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
